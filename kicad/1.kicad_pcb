# Repository demicchi/eeprom-player-attiny202

## KiCad design kicad/1.kicad_pcb

Parts:
C1: 0.33u; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
J1: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
J2: AudioJack4; TRRS_Breakout
J3: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.54mm_Vertical
Q1: 2SJ681; 2SJ681_2-7J2B_Vertical
Q2: 2SK4017; 2SK4017_2-7J2B_Vertical_1
R1, R2: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R5, R6: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: AMS1117-5V
U2: TLP785; DIP-4_W7.62mm
U3: ATtiny202-SS; DIP-8_W7.62mm
U4, U5, U6, U7: 24LC512; DIP-8_W7.62mm_Socket
U8: AMP_PAM8403_Volume

Connections:
+5V: J1.1, R1.1, R2.1, U1.3 (VOUT), U2.4, U3.1 (VCC), U4.7 (WP), U4.8 (VCC), U5.1 (A0), U5.7 (WP), U5.8 (VCC), U6.2 (A1), U6.7 (WP), U6.8 (VCC), U7.1 (A0), U7.2 (A1), U7.7 (WP), U7.8 (VCC), U8.4 (PWR+)
+12V: Q1.2 (D), U1.1 (VIN)
+12V(ACC): D1.2 (A), J3.2, R3.1
+12V(B+): J3.1, Q1.3 (S), R4.1
ACC_SENSE: R6.2, R7.1, U3.7 (PA3)
GND: C1.2, J1.2, J2.S, J3.3, Q2.3 (S), R7.2, R8.2, U1.2 (GND), U1.4 (GND), U2.2, U3.8 (GND), U4.1 (A0), U4.2 (A1), U4.3 (A2), U4.4 (GND), U5.2 (A1), U5.3 (A2), U5.4 (GND), U6.1 (A0), U6.3 (A2), U6.4 (GND), U7.3 (A2), U7.4 (GND), U8.2 (IN_G), U8.5 (PWR-)
unnamed: D1.1 (K), D2.1 (K), Q2.1 (G), R8.1
unnamed: D2.2 (A), R5.2
unnamed: Q1.1 (G), Q2.2 (D), R4.2
unnamed: R3.2, U2.1
unnamed: R6.1, U2.3
unnamed: C1.1, R9.2, U8.3 (IN_L)
unnamed: J2.T, U8.7 (L_OUT+)
PWR_SW: R5.1, U3.3 (PA7)
SCL: R2.2, U3.5 (PA2), U4.6 (SCL), U5.6 (SCL), U6.6 (SCL), U7.6 (SCL)
SDA: R1.2, U3.4 (PA1), U4.5 (SDA), U5.5 (SDA), U6.5 (SDA), U7.5 (SDA)
UPDI: J1.3, U3.6 (~RESET/PA0)
WAVE: R9.1, U3.2 (PA6)

Notes on the sheet:
5V降圧
マイコン
KiCAD ERCエラー抑止
12V電源制御
-3dBカットオフ周波数=4823Hz
音声出力
電源コネクタ
UPDI

Board: 2 copper layers, 94.0 x 71.1 mm, 25 parts (0 on the bottom side), 18 nets.

## Commit log

2024-10-26 initial
